## espwebemu/test-firmware/sdkconfig.defaults
```kconfig
# Target ESP32
CONFIG_IDF_TARGET="esp32"
# Enable QEMU support
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
```
